FILESEXTRAPATHS:prepend := "${THISDIR}/${PN}:"

SRC_URI += " file://autoboot_Not_stop.patch "

