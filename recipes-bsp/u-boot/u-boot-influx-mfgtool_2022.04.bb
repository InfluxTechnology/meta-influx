require u-boot-influx_${PV}.bb
require recipes-bsp/u-boot/u-boot-mfgtool.inc
