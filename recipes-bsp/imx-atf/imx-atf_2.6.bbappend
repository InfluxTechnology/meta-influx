FILESEXTRAPATHS:prepend := "${THISDIR}/files:"

SRC_URI += "file://Allocate-UART4-to-domain-0.patch"
